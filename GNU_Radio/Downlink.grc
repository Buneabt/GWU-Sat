options:
  parameters:
    author: bogdanbunea
    generate_options: qt_gui
    id: WorkingModel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Center_Freq
  id: variable_qtgui_range
  parameters:
    start: '144350000'
    step: '100000'
    stop: '144450000'
    value: '144390000'
    widget: eng_slider
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '48000'
    quad_rate: '100000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /Users/bogdanbunea/Desktop/ax_25_packet_document.txt
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate/(decimation*baud_rate)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '5'
    gain: '0'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Our Main Source
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Filters out excessive noise
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Gives timing information to all of our bits
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: Demodulates the FM signal and converts complex samples to audio
  states: {}
- name: note_0_1_0_1
  id: note
  parameters:
    note: 'onverts continuous signal into digital 1s and 0s '
  states: {}
- name: note_0_1_0_2
  id: note
  parameters:
    note: Extracts AX.25 Packets from bit stream, checks fram integrity
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '10000'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: Center_Freq
    fftsize: '4096'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: Center_Freq
    gain0: '100'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print]
- [satellites_hdlc_deframer_0, out, blocks_message_debug_1, print]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
