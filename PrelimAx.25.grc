options:
  parameters:
    author: bogdanbunea
    generate_options: qt_gui
    id: PrelimAx.25
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CenterFreq
  id: variable
  parameters:
    value: '436420000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: '.25'
    mu: '0.5'
    omega: '8'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4800'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: CenterFreq
    gain0: '15.5'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', satellites_ax25_deframer_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rtlsdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print]
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, store]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
